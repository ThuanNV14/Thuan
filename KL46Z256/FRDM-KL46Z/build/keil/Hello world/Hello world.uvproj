# Keil uVision project Hello world.uvproj, settings and files
target Hello world (ARM-ADS)
  device: MKL46Z256xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Hello world
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  group startup
    ./: startup_MKL46Z4.s
